SRC_URI_append_qemuarm64 = " file://restart-rngd.diff;patchdir=${WORKDIR}"
