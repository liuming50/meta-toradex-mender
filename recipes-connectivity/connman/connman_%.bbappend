RPROVIDES_${PN}_append = " network-configuration"
